BBCLASSEXTEND += " nativesdk "

RDEPENDS:${PN}:class-nativesdk:remove = " ${PN}-dev"