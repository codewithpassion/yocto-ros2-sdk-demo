# Needed for nativesdk-ros2cli to work.
BBCLASSEXTEND += " nativesdk "