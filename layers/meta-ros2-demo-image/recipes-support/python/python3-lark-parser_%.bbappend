BBCLASSEXTEND += " nativesdk "